options:
  parameters:
    generate_options: qt_gui
    id: Freq_mod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Modulation
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_frequency_modulator_fc_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '314.16'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '3.18'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: Freq_mod.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: E:\Semester 06\Communication Systems\Project\Freq_mod.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[0]*1000 + [1] + [0]*1000 + [1]'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: E:\Semester 06\Communication Systems\Project\counting.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_frequency_modulator_fc_1, '0', blocks_file_sink_1, '0']
- [analog_frequency_modulator_fc_1, '0', qtgui_time_sink_x_1, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_1, '0', analog_frequency_modulator_fc_1, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_throttle2_1, '0', blocks_add_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_add_xx_1, '0']
- [blocks_wavfile_source_1, '0', blocks_throttle2_1, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
